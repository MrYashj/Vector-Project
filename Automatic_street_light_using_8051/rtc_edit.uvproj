# Keil uVision project rtc_edit.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: rtc_edit +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 I2C_DR.C ISR_DR.C LCD_DR.C MAIN_DR.C delay.c driver_keypad.c main1.c ISR_DR1.c
